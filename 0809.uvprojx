# Keil uVision project 0809.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: 0809
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\0809.sct
  group Ports
    ./src/: port.c
  group user
    ./src/: main.c list.c
  group Source
    ./src/: task.c
  group include
    ./include/: list.h FreeRTOS.h FreeRTOSConfig.h portable.h portmacro.h projdefs.h task.h port.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.3
